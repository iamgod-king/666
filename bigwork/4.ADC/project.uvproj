# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\4.ADC
  group Source Group 1
    ./: STARTUP.A51 main.c XPT2046.c XPT2046.h LCD1602.h LCD1602.c Delay.h Delay.c
